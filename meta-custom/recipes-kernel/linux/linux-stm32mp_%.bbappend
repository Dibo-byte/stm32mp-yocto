FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-add-i2c5-userspace-dts.patch"
SRC_URI += "file://0002-add-spi4-userspace-dts.patch"



